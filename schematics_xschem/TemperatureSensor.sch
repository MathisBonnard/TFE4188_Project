v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 890 -1170 890 -780 {
lab=VDD_1V8}
N 790 -1170 890 -1170 {
lab=VDD_1V8}
N 970 -720 1010 -720 {
lab=#net1}
N 1010 -900 1010 -720 {
lab=#net1}
N 1010 -900 1070 -900 {
lab=#net1}
N 770 -900 1070 -900 {
lab=#net1}
N 830 -600 1110 -600 {
lab=VT_out}
N 890 -660 890 -360 {
lab=VSS}
N 1110 -600 1110 -590 {
lab=VT_out}
N 730 -1060 730 -930 {
lab=VDD_1V8}
N 730 -1060 890 -1060 {
lab=VDD_1V8}
N 890 -1060 1110 -1060 {
lab=VDD_1V8}
N 1110 -1060 1110 -930 {
lab=VDD_1V8}
N 610 -900 730 -900 {
lab=VDD_1V8}
N 610 -1030 610 -900 {
lab=VDD_1V8}
N 610 -1030 730 -1030 {
lab=VDD_1V8}
N 1110 -1030 1220 -1030 {
lab=VDD_1V8}
N 1220 -1030 1220 -900 {
lab=VDD_1V8}
N 1110 -900 1220 -900 {
lab=VDD_1V8}
N 1130 -560 1210 -560 {
lab=VSS}
N 890 -360 1210 -360 {
lab=VSS}
N 1110 -530 1110 -490 {
lab=#net2}
N 730 -600 730 -490 {
lab=#net3}
N 690 -460 690 -390 {
lab=VSS}
N 690 -390 890 -390 {
lab=VSS}
N 890 -390 1070 -390 {
lab=VSS}
N 1070 -460 1070 -390 {
lab=VSS}
N 1110 -430 1110 -360 {
lab=VSS}
N 730 -430 730 -390 {
lab=VSS}
N 730 -770 730 -600 {
lab=#net3}
N 730 -770 760 -800 {
lab=#net3}
N 730 -870 760 -860 {
lab=#net3}
N 1110 -770 1110 -600 {
lab=VT_out}
N 1110 -770 1150 -800 {
lab=VT_out}
N 1110 -870 1150 -860 {
lab=VT_out}
N 760 -860 760 -800 {
lab=#net3}
N 1150 -860 1150 -800 {
lab=VT_out}
N 780 -670 780 -660 {
lab=VT_out}
N 1210 -560 1210 -360 {
lab=VSS}
N 800 -710 820 -710 {
lab=#net3}
N 780 -720 780 -670 {
lab=VT_out}
N 780 -730 780 -720 {
lab=VT_out}
N 780 -730 820 -730 {
lab=VT_out}
N 730 -710 800 -710 {
lab=#net3}
N 780 -600 830 -600 {
lab=VT_out}
N 780 -660 780 -600 {
lab=VT_out}
N 1670 -210 1730 -210 {
lab=#net4}
N 1670 -350 1730 -350 {
lab=#net5}
N 1670 -490 1730 -490 {
lab=#net6}
N 1670 -630 1730 -630 {
lab=#net7}
N 1670 -770 1730 -770 {
lab=#net8}
N 1670 -910 1730 -910 {
lab=#net9}
N 1670 -1050 1730 -1050 {
lab=#net10}
N 1590 -250 1680 -250 {
lab=VDD_1V8}
N 1590 -390 1680 -390 {
lab=VDD_1V8}
N 1590 -950 1680 -950 {
lab=VDD_1V8}
N 1590 -810 1680 -810 {
lab=VDD_1V8}
N 1590 -670 1680 -670 {
lab=VDD_1V8}
N 1590 -530 1680 -530 {
lab=VDD_1V8}
N 1590 -1090 1680 -1090 {
lab=VDD_1V8}
N 1590 -1010 1670 -1010 {
lab=VSS}
N 1590 -870 1670 -870 {
lab=VSS}
N 1590 -730 1670 -730 {
lab=VSS}
N 1590 -590 1670 -590 {
lab=VSS}
N 1590 -450 1670 -450 {
lab=VSS}
N 1590 -310 1670 -310 {
lab=VSS}
N 1590 -170 1670 -170 {
lab=VSS}
N 1500 -1060 1520 -1060 {
lab=VT_out}
N 1500 -220 1520 -220 {
lab=VT_out}
N 1500 -360 1520 -360 {
lab=VT_out}
N 1500 -500 1520 -500 {
lab=VT_out}
N 1500 -640 1520 -640 {
lab=VT_out}
N 1500 -780 1520 -780 {
lab=VT_out}
N 1500 -920 1520 -920 {
lab=VT_out}
N 1490 -1110 1490 -1040 {
lab=#net11}
N 1490 -1040 1520 -1040 {
lab=#net11}
N 1490 -1040 1490 -1010 {
lab=#net11}
N 1490 -950 1490 -870 {
lab=#net12}
N 1490 -810 1490 -730 {
lab=#net13}
N 1490 -670 1490 -590 {
lab=#net14}
N 1490 -900 1520 -900 {
lab=#net12}
N 1490 -760 1520 -760 {
lab=#net13}
N 1490 -620 1520 -620 {
lab=#net14}
N 1490 -530 1490 -450 {
lab=#net15}
N 1490 -390 1490 -310 {
lab=#net16}
N 1490 -340 1520 -340 {
lab=#net16}
N 1490 -480 1520 -480 {
lab=#net15}
N 1490 -250 1490 -170 {
lab=#net17}
N 1490 -200 1520 -200 {
lab=#net17}
N 1680 -1150 1680 -250 {
lab=VDD_1V8}
N 1470 -220 1500 -220 {
lab=VT_out}
N 1470 -360 1500 -360 {
lab=VT_out}
N 1470 -500 1500 -500 {
lab=VT_out}
N 1470 -1060 1500 -1060 {
lab=VT_out}
N 1470 -920 1500 -920 {
lab=VT_out}
N 1470 -780 1500 -780 {
lab=VT_out}
N 1470 -640 1500 -640 {
lab=VT_out}
N 1650 -1170 1680 -1170 {
lab=VDD_1V8}
N 1680 -1170 1680 -1150 {
lab=VDD_1V8}
N 1700 -1010 1700 -80 {
lab=VSS}
N 1670 -1010 1700 -1010 {
lab=VSS}
N 1670 -870 1700 -870 {
lab=VSS}
N 1670 -730 1700 -730 {
lab=VSS}
N 1670 -590 1700 -590 {
lab=VSS}
N 1670 -310 1700 -310 {
lab=VSS}
N 1670 -170 1700 -170 {
lab=VSS}
N 1670 -450 1700 -450 {
lab=VSS}
N 1420 -60 1700 -60 {
lab=VSS}
N 1700 -80 1700 -60 {
lab=VSS}
N 1880 -630 1900 -630 {
lab=#net10}
N 1880 -1050 1880 -630 {
lab=#net10}
N 1730 -1050 1880 -1050 {
lab=#net10}
N 1730 -910 1860 -910 {
lab=#net9}
N 1860 -910 1860 -610 {
lab=#net9}
N 1860 -610 1900 -610 {
lab=#net9}
N 1840 -590 1900 -590 {
lab=#net8}
N 1840 -770 1840 -590 {
lab=#net8}
N 1730 -770 1840 -770 {
lab=#net8}
N 1730 -630 1820 -630 {
lab=#net7}
N 1820 -630 1820 -570 {
lab=#net7}
N 1820 -570 1900 -570 {
lab=#net7}
N 1820 -550 1900 -550 {
lab=#net6}
N 1820 -550 1820 -490 {
lab=#net6}
N 1730 -490 1820 -490 {
lab=#net6}
N 1730 -350 1840 -350 {
lab=#net5}
N 1840 -530 1840 -350 {
lab=#net5}
N 1840 -530 1900 -530 {
lab=#net5}
N 1860 -510 1900 -510 {
lab=#net4}
N 1860 -510 1860 -210 {
lab=#net4}
N 1730 -210 1860 -210 {
lab=#net4}
N 1700 -60 2050 -60 {
lab=VSS}
N 2050 -440 2050 -60 {
lab=VSS}
N 1880 -490 1900 -490 {
lab=VSS}
N 1880 -490 1880 -60 {
lab=VSS}
N 2050 -1160 2050 -680 {
lab=VDD_1V8}
N 2050 -1170 2050 -1160 {
lab=VDD_1V8}
N 1680 -1170 2050 -1170 {
lab=VDD_1V8}
N 2200 -620 2220 -620 {
lab=Vout_A}
N 2200 -580 2220 -580 {
lab=Vout_B}
N 2200 -540 2220 -540 {
lab=Vout_C}
N 2200 -500 2220 -500 {
lab=Vout_D}
N 1420 -1060 1470 -1060 {
lab=VT_out}
N 1470 -1060 1470 -220 {
lab=VT_out}
N 1420 -1170 1650 -1170 {
lab=VDD_1V8}
N 700 -60 1420 -60 {
lab=VSS}
N 890 -350 890 -60 {
lab=VSS}
N 890 -360 890 -350 {
lab=VSS}
N 1110 -600 1320 -600 {
lab=VT_out}
N 1320 -1050 1320 -600 {
lab=VT_out}
N 1320 -1060 1420 -1060 {
lab=VT_out}
N 1320 -1060 1320 -1050 {
lab=VT_out}
N 1490 -110 1490 -60 {
lab=VSS}
N 1320 -960 1340 -960 {
lab=VT_out}
N 890 -1170 1420 -1170 {
lab=VDD_1V8}
C {devices/ipin.sym} 790 -1170 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 700 -60 0 0 {name=p2 lab=VSS}
C {sky130_fd_pr/res_high_po.sym} 1110 -560 0 1 {name=R1
W=4
L=10
model=res_high_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 1090 -900 0 0 {name=M3[9:0]
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 750 -900 0 1 {name=M4[9:0]
L=1
W=10
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 710 -460 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 1090 -460 0 0 {name=Q2[7:0]
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {RPLY_EX0_SKY130NM/RPLY_MAINOPAMP.sym} 970 -720 0 0 {name=x3}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -1050 0 0 {name=x1}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -910 0 0 {name=x2}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -770 0 0 {name=x4}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -630 0 0 {name=x5}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -490 0 0 {name=x6}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -350 0 0 {name=x7}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -140 0 0 {name=R8
W=1
L=42
model=res_generic_l1
mult=1}
C {RPLY_EX0_SKY130NM/OpAmp.sym} 1670 -210 0 0 {name=x8}
C {devices/opin.sym} 2220 -620 0 0 {name=p8 lab=Vout_A}
C {devices/opin.sym} 2220 -580 0 0 {name=p9 lab=Vout_B}
C {devices/opin.sym} 2220 -540 0 0 {name=p10 lab=Vout_C}
C {devices/opin.sym} 2220 -500 0 0 {name=p12 lab=Vout_D}
C {RPLY_EX0_SKY130NM/8to4Encoder.sym} 2050 -560 0 0 {name=x9}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -280 0 0 {name=R7
W=1
L=1
model=res_generic_l1
mult=1}
C {devices/opin.sym} 1340 -960 0 0 {name=p4 lab=VT_out}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -420 0 0 {name=R2
W=1
L=1
model=res_generic_l1
mult=1}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -560 0 0 {name=R3
W=1
L=1
model=res_generic_l1
mult=1}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -700 0 0 {name=R4
W=1
L=1
model=res_generic_l1
mult=1}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -840 0 0 {name=R5
W=1
L=1
model=res_generic_l1
mult=1}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -980 0 0 {name=R6
W=1
L=1
model=res_generic_l1
mult=1}
C {sky130_fd_pr/res_generic_l1.sym} 1490 -1140 0 0 {name=R9
W=1
L=54
model=res_generic_l1
mult=1}
